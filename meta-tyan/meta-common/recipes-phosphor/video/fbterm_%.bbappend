FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

DEPENDS_append = " tyan-early-vga"
