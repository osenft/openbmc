FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI_append = " \
 file://0002-frup-Add-support-for-BCD-plus-and-6-bit-ASCII-packed.patch \
"
