FILESEXTRAPATHS_prepend_s7106 := "${THISDIR}/${PN}:"
SRC_URI_append_s7106 = " file://s7106.cfg"
