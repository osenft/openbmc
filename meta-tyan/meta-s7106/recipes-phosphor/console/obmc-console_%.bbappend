OBMC_CONSOLE_HOST_TTY_s7106 = "ttyS2"
