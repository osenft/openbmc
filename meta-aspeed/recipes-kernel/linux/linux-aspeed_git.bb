KBRANCH ?= "tyan-5.2"
LINUX_VERSION ?= "5.2.14"

SRCREV="dc0e85ba2c6b6d30a35359633e5d8c409a9a034a"

require linux-aspeed.inc
